# Keil uVision project lab4.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Lab1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: "C:\Users\A02390656\Downloads\additionalCFiles"
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6314W
  group Source Group 1
    ../Lab04_LCD/: LCD.c LCD.h main.c startup_stm32l476xx.s stm32l476xx.h handlers.h handlers.c
    ../../Downloads/additionalCFiles/: core_cm4_constants.s stm32l4xx.h system_stm32l4xx.c system_stm32l4xx.h
software components: CMSIS:CORE 6.1.1
